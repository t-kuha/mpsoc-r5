## zephyr/src/ultra96v2/Kconfig.ultra96v2
```kconfig
# Copyright (c) 2020, Antmicro
# SPDX-License-Identifier: Apache-2.0

config BOARD_ULTRA96V2
	select SOC_XILINX_ZYNQMP_RPU
```
